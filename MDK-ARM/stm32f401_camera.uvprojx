# Keil uVision project stm32f401_camera.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F401VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32f401_camera +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401x6
  c misc: -Wno-invalid-utf8 -Wno-empty-translation-unit -Wno-padded -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-cast-align -Wno-switch-enum -Wno-covered-switch-default -Wno-implicit-int-conversion -Wno-bad-function-cast -Wno-missing-variable-declarations
  c include: ..\CMSIS;..\CMSIS\m-profile;..\Library\Inc;..\Library\Inc\Legacy;..\Library\Src;..\Library\Src\Legacy;..\User\inc;..\User\src;..\BSP\inc;..\BSP\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Library\Src
    ../Library/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Library\Src\Legacy
    ../Library/Src/Legacy/: stm32f4xx_hal_can.c stm32f4xx_hal_eth.c
  group Start
    ../Start/: startup_stm32f401xe.s
  group User\inc
    ../User/inc/: main.h stm32f4xx_hal_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group User\src
    ../User/src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP\inc
    ../BSP/inc/: emount_protocol.h gpio_config.h key.h delay.h sys.h
  group BSP\src
    ../BSP/src/: emount_protocol.c gpio_config.c usart_config.c key.c delay.c sys.c
